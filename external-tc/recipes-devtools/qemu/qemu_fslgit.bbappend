EXTRA_OEMAKE_append_e5500-64b = 'AS="${AS} -a64"'
EXTRA_OEMAKE_append_e6500-64b = 'AS="${AS} -a64"'
