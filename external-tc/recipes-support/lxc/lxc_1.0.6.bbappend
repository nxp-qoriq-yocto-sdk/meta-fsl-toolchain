FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://0001-fix-the-definition-conflict-issue-of-setns.patch"
