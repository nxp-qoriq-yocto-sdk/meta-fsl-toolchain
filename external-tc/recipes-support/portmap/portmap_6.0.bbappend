DEPENDS_append = " libtirpc"

LDFLAGS_append = " -ltirpc"
